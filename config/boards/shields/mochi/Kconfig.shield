## config/boards/shields/mochi/Kconfig.shield
```kconfig
# Aidan Smith (2021)
# SPDX-License-Identifier: MIT

config SHIELD_mochi
	def_bool $(shields_list_contains,mochi)
```
